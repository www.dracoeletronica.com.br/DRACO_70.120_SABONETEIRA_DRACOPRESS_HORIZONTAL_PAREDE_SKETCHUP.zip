Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.120_SABONETEIRA_DRACOPRESS_HORIZONTAL_PAREDE.IFC
Time: 2023-12-07T18:17:02
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.120_SABONETEIRA_DRACOPRESS_HORIZONTAL_PAREDE
In: Default Storey
Material: AISI 304
PSet_Mass_Property - Mass Measure: 11.0147; Area Measure: 0.104442 m2; Volume Measure: 0.00137684 m3
